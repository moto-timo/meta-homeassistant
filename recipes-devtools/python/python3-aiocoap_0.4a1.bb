SUMMARY = "Python CoAP library"
HOMEPAGE = "https://github.com/chrysn/aiocoap"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=afaf767baa20ac524dc12f1071ca493a"

inherit pypi setuptools3

SRC_URI[md5sum] = "0f8d062b307cbd9d4f5decf8d194a7b3"
SRC_URI[sha256sum] = "3be55f62a27409f7c6b76b3744999a20eeedf9d3f705d085055e28a3cf6460e7"
